# Keil uVision project pmsm_encoder_foc.uvprojx, settings and files
target pmsm_encoder_foc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: pmsm_encoder_foc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\..\Library\CMSIS\Include;..\..\Library\CMSIS\Device\ST\STM32H7xx\Include;..\..\Library\STM32H7xx_HAL_Driver\Inc;..\..\User\fw\pmsm_ctrl;..\..\User\fw\delay;..\..\User\fw\key_bsp;..\..\User\fw\led_bsp;..\..\User\fw\sys;..\..\User\fw\uart_bsp;..\..\User\fw
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group startup
    ../../Library/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group cmsis
    ../../Library/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group stm32h7xx_hal_driver
    ../../Library/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c
  group user
    ../../User/fw/: main.c stm32h7xx_it.c
    ../../User/fw/sys/: sys.c
    ../../User/fw/delay/: core_delay.c
  group bsp
    ../../User/fw/key_bsp/: key_bsp.c
    ../../User/fw/led_bsp/: led_bsp.c
    ../../User/fw/uart_bsp/: usart_bsp.c
  group pmsm
    ../../User/fw/pmsm_ctrl/: commutation.c emf_zerodetect.c pid_ctrl.c pmsm_sys_ctrl.c pmsm_sys_pmsm_drive.c pmsm_sys_pmsm_feedback.c pmsm_sys_tim_callback.c pwm.c sensorless_ctrl.c vvvf.c encoder.c adc.c dma.c
